# Keil uVision project Project.uvprojx, settings and files
target lpc1768 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  ./Objects/Project.axf --output ./build/bootloader.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\drivers;..\..\include;..\..\components\finsh;..\lpc176x_blink;.\;..\..\components\utilities\;..\..\components\utilities\zmodem;..\..\components\dfs\include;.\applications
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Applications
    ./applications/: main.c boot_iap.c md5sum.c
  group Drivers
    ./drivers/: board.c uart.c lpc_ipc.c
  group Libraries
    ./libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./libraries/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ./libraries/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
    ../../libcpu/arm/cortex-m3/: context_rvds.S
  group RTOS
    ../../components/device/: device.c
    ../../src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../libcpu/arm/cortex-m3/: cpuport.c
  group finsh
    ../../components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group utilities
    ../../components/utilities/: ymodem.c
